# Keil uVision project Project.uvprojx, settings and files
target STM324xG-EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32CubeDemo_STM324xG-EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM324xG_EVAL,USE_USB_HS
  c include: ../Core/Inc;../Config;../../../../../Utilities/CPU;../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM324xG_EVAL;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STemWin/inc;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: videoplayer_win.c
  group Application/User/Modules/USBDevice
    ../Modules/usbdevice/: usbd_win.c usbd_desc.c usbd_storage.c usbd_app.c
  group Middlewares/USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/Modules/ImageBrowser
    ../Modules/imagebrowser/: imagebrowser_win.c
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Application/User/Modules/Camera
    ../Modules/camera/: camera_app.c camera_win.c
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Drivers/BSP/Components/ov2640/: ov2640.c
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USBD_Library/Config
    ../Config/: usbd_conf.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Middlewares/USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval.c stm324xg_eval_sram.c stm324xg_eval_lcd.c stm324xg_eval_camera.c stm324xg_eval_audio.c stm324xg_eval_sd.c stm324xg_eval_io.c stm324xg_eval_ts.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Application/User/Modules/Game
    ../Modules/game/: game_win.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM4_OS_Keil.lib
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Modules/AudioPlayer
    ../Modules/audioplayer/: audioplayer_win.c audioplayer_app.c
  group Application/User/Modules/Benchmark
    ../Modules/benchmark/: benchmark_win.c
  group Middlewares/STemWin/Config
    ../Config/: LCDConf.c GUIConf.c
  group Application/User/Modules/FileBrowser
    ../Modules/filebrowser/: filebrowser_win.c filebrowser_app.c
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c list.c croutine.c queue.c
  group Application/User/Modules/System
    ../Modules/system/: system_win.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Application/User/Core
    ../Core/Src/: k_rtc.c k_menu.c stm32f4xx_it.c k_module.c k_mem.c main.c k_storage.c k_bsp.c stm32f4xx_hal_timebase_tim.c k_calibration.c k_modules_res.c k_log.c k_startup.c
  group Middlewares/USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c usbh_core.c
  group Drivers/STM32F4xx_HAL_Drivers
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal.c stm32f4xx_ll_usb.c stm32f4xx_hal_nand.c stm32f4xx_hal_tim.c stm32f4xx_hal_usart.c stm32f4xx_hal_nor.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_eth.c stm32f4xx_hal_hcd.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_can.c stm32f4xx_hal_pccard.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_adc.c stm32f4xx_hal_msp_template.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_hash.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_cryp.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2s.c
  group Middlewares/FatFs/Drivers
    ../Config/: usbh_diskio.c sd_diskio.c
  group Middlewares/USBD_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_data.c usbd_msc.c usbd_msc_bot.c usbd_msc_scsi.c
software components: CMSIS:CORE 4.3.0
