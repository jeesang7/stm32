# Keil uVision project Project.uvprojx, settings and files
target STM32446E_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_IOEXPANDER
  c include: ../Core/Inc;../STemWin/App;../STemWin/Target;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32446E_EVAL;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/ili9325;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Utilities;../../../../../../Utilities/Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_io.c stm32446e_eval.c stm32446e_eval_ts.c
  group Middlewares/STemWin/Config
    ../STemWin/Target/: LCDConf_stm32446e_eval.c GUIConf_stm32446e_eval.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM4_Keil.lib
  group Application/Demo
    ../STemWin/App/: GUIDEMO_BarGraph.c GUIDEMO_Resource.c GUIDEMO_Automotive.c GUIDEMO_Cursor.c GUIDEMO_Conf.c GUIDEMO_ColorBar.c GUIDEMO_Speed.c GUIDEMO_TransparentDialog.c GUIDEMO_Intro.c GUIDEMO_Treeview.c GUIDEMO_Listview.c GUIDEMO_Start.c GUIDEMO.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_flash.c
  group Application/User
    ../Core/Src/: stm32f4xx_it.c main.c
    ../STemWin/Target/: rtc.c calibration.c
software components: CMSIS:CORE 4.3.0
