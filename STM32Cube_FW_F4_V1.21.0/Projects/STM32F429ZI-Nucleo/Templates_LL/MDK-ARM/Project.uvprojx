# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-F429ZI (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: NUCLEO-F429ZI
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F429xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers/STM32F4xx_HAL_Driver/Inc
  library: MicroLIB
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_LL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_crc.c stm32f4xx_ll_i2c.c stm32f4xx_ll_pwr.c stm32f4xx_ll_exti.c stm32f4xx_ll_usart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_spi.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_dma.c stm32f4xx_ll_adc.c stm32f4xx_ll_lptim.c stm32f4xx_ll_tim.c stm32f4xx_ll_rng.c stm32f4xx_ll_utils.c stm32f4xx_ll_rtc.c stm32f4xx_ll_dac.c stm32f4xx_ll_rcc.c
  group Example/User
    ../Src/: main.c stm32f4xx_it.c
software components: CMSIS:CORE 4.3.0
