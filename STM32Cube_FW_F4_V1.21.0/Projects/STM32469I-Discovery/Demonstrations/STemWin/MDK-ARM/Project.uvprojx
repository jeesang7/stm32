# Keil uVision project Project.uvprojx, settings and files
target STM32469I-DISCO_Demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32469I-DISCO_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F469xx,USE_HAL_DRIVER,USE_STM32469I_DISCOVERY,USE_USB_FS,USE_IOEXPANDER
  c include: ../Config;../Gui/STemWin_Addons;../Gui/Target;../Core/Inc;../../../../../Utilities/CPU;../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32469I-Discovery;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STemWin/inc;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Modules/audio_player/Addons/SpiritDSP_Equalizer;../Modules/audio_player/Addons/SpiritDSP_LoudnessControl;../Modules/audio_player;../Modules/audio_recorder;../Modules/Common
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STM32469I-DISCO_Demo\Exe\STM32469I-DISCO_Demo.sct
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FatFs/Drivers
    ../Config/: usbh_diskio.c
  group Drivers/STM32F4_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pccard.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_can.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_uart.c stm32f4xx_hal_eth.c stm32f4xx_hal_irda.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_sai.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_hash.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_pcd.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_sram.c stm32f4xx_hal_dac.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_hcd.c stm32f4xx_hal_crc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_nand.c
  group Application/User/Modules/Audio/Addons
    ../Modules/audio_player/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m4.a
    ../Modules/audio_player/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m4.a
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Application/User/Modules/Common
    ../Modules/Common/: audio_if.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c list.c croutine.c timers.c queue.c event_groups.c
  group Application/User/Modules/audio_recorder
    ../Modules/audio_recorder/: audio_recorder_app.c
    ../Gui/Core/audio_recorder/: audio_recorder_win.c
  group Middlewares/STemWin/Config
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM4_OS_Keil_ot.lib
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Middlewares/USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c
  group Application/User/Core
    ../Core/Src/: stm32f4xx_hal_timebase_tim.c k_rtc.c stm32f4xx_it.c k_menu.c main.c k_bsp.c k_storage.c k_module.c k_startup.c
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group Application/User/Modules/home_alarm
    ../Gui/Core/home_alarme/: home_alarm_win.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STM32469I-Discovery_STemWin_Addons_KEIL.lib
  group Application/User/Modules/VideoPlayer
    ../Gui/Core/videoplayer/: video_player_win.c
  group Application/User/Modules/gardening_control
    ../Gui/Core/gardening_control/: gardening_control_win.c
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil.lib
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_app.c
    ../Gui/Core/audio_player/: audio_player_win.c
  group Drivers/BSP/STM32469I_DISCO
    ../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery_ts.c stm32469i_discovery_sdram.c stm32469i_discovery.c stm32469i_discovery_audio.c stm32469i_discovery_sd.c stm32469i_discovery_qspi.c
  group Application/User/Modules/third_party
    ../Gui/Core/thirdparty/: third_party_win.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/STemWin/OS
    ../Config/: GUI_X_FreeRTOS.c
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Application/User/Modules/sys_info
    ../Gui/Core/settings/: settings_win.c
  group Application/User/Modules/games
    ../Gui/Core/games/: games_win.c
software components: CMSIS:CORE 4.3.0
