# Keil uVision project Project.uvprojx, settings and files
target STM32469I_DISCOVERY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32469I_DISCOVERY +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32469I-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STM32469I_DISCOVERY\STM32469I_DISCOVERY.sct
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: main.c stm32f4xx_it.c
  group Drivers/BSP/STM32469I-Discovery
    ../../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/MDK-ARM
    ./: startup_stm32f469xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c
software components: CMSIS:CORE 4.3.0
