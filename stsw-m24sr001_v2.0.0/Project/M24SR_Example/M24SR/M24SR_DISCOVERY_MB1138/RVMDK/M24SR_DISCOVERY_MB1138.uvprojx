# Keil uVision project M24SR_DISCOVERY_MB1138.uvprojx, settings and files
target M24SR_DISCOVERY_MB1138 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: M24SR_DISCOVERY_MB1138 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_XL
  c include: ..\inc;..\..\..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\..\Libraries\M24SR\inc;..\..\..\..\..\Utilities\M24SR_DISCOVERY_MB1138\LCD\inc;..\..\..\..\..\Utilities\M24SR_DISCOVERY_MB1138\LCD\pictures;..\..\..\..\..\Utilities\M24SR_DISCOVERY_MB1138\LED\inc;..\..\..\..\..\Utilities\M24SR_DISCOVERY_MB1138\BLUETOOTH\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User_Appli
    ../src/: main.c menu.c hw_config.c stm32f10x_it.c
  group M24SR_Driver
    ../../../../../Libraries/M24SR/src/: drv_I2C_M24SR.c drv_M24SR.c
  group M24SR_Libraries
    ../../../../../Libraries/M24SR/src/: lib_M24SR.c
  group NFC_Libraries
    ../../../../../Libraries/M24SR/src/: lib_TagType4.c lib_NDEF_URI.c lib_NDEF_SMS.c lib_NDEF_Email.c lib_NDEF_Vcard.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_AAR.c lib_NDEF.c lib_ISO7816_Password.c lib_STProprietary_feature.c
  group StdPeriph_Driver
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User_Drivers
    ../../../../../Utilities/M24SR_DISCOVERY_MB1138/LED/src/: drv_LED.c
    ../../../../../Utilities/M24SR_DISCOVERY_MB1138/LCD/src/: drv_lcdspi_ili9341.c
    ../../../../../Utilities/M24SR_DISCOVERY_MB1138/BLUETOOTH/src/: drv_bluetooth.c
  group MDK-ARM
    ./: startup_stm32f10x_xl.s
  group CMSIS
    ../../../../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
