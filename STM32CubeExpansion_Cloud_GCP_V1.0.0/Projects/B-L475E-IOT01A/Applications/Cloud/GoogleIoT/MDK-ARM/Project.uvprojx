# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_GoogleIoT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,SENSOR,MBEDTLS_CONFIG_FILE=<googleiot_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,GOOGLEIOT,USE_MBED_TLS,USE_WIFI
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../Inc;../../../../../Common/GoogleIoT/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/cJSON;../../../../../../Drivers/BSP/Components/es_wifi;../../../../../../Drivers/BSP/Components/hts221;../../../../../../Drivers/BSP/Components/lis3mdl;../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../Drivers/BSP/Components/lsm6dsl;../../../../../../Drivers/BSP/Components/vl53l0x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\B-L475E-IOT01.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User
    ../Src/: stm32l4xx_it.c vl53l0x_proximity.c vl53l0x_platform.c main.c stm32l4xx_hal_msp.c
  group Middlewares/Third_Party/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: debug.c ripemd160.c x509write_csr.c cipher_wrap.c camellia.c threading.c x509.c ssl_tls.c x509_csr.c x509_crl.c version_features.c pk.c md_wrap.c platform.c sha512.c pkcs5.c padlock.c cipher.c ssl_cookie.c asn1write.c entropy.c dhm.c error.c ssl_ticket.c blowfish.c ctr_drbg.c entropy_poll.c version.c pkwrite.c des.c xtea.c arc4.c gcm.c cmac.c certs.c ecp.c oid.c pkparse.c asn1parse.c sha256.c pem.c memory_buffer_alloc.c md.c ecp_curves.c ecdh.c pk_wrap.c ssl_cache.c x509_crt.c ecjpake.c rsa.c hmac_drbg.c pkcs12.c ssl_srv.c x509_create.c aria.c platform_util.c rsa_internal.c md5.c ccm.c aesni.c timing.c sha1.c bignum.c ssl_cli.c x509write_crt.c pkcs11.c md4.c base64.c havege.c ssl_ciphersuites.c ecdsa.c aes.c md2.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_platform_log.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_api_core.c vl53l0x_api_calibration.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_wwdg.c stm32l4xx_hal_nor.c stm32l4xx_hal_rtc.c stm32l4xx_hal.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_gpio.c stm32l4xx_ll_fmc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_lptim.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_i2c.c stm32l4xx_hal_uart.c stm32l4xx_hal_hash.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_dac.c stm32l4xx_hal_pwr.c stm32l4xx_hal_cryp.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_usart.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_cortex.c
  group Application/Wifi
    ../Src/: wifi.c es_wifi_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/Common
    ../../../../../Common/Shared/Src/: entropy_hardware_poll.c sensors_data.c iot_flash_config.c net_tls_mbedtls.c net.c rfu.c heap.c timedate.c net_tcp_wifi.c STM32CubeRTCInterface.c http_lib.c paho_timer.c timingSystem.c wifi_net.c mbedtls_net.c cloud.c
    ../Src/: flash_l4.c
  group Application/GoogleIoT
    ../../../../../Common/GoogleIoT/Src/: jwt.c googleiot.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01.c stm32l475e_iot01_psensor.c stm32l475e_iot01_gyro.c stm32l475e_iot01_accelero.c stm32l475e_iot01_tsensor.c
  group Middlewares/Third_Party/MQTTPacket
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTUnsubscribeServer.c MQTTSubscribeServer.c MQTTConnectServer.c MQTTPacket.c MQTTSerializePublish.c MQTTDeserializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c MQTTConnectClient.c MQTTFormat.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON_Utils.c cJSON.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
software components: CMSIS:CORE 5.0.1
