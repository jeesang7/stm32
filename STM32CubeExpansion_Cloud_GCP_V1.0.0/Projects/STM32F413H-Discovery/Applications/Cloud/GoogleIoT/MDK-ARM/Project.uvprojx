# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY_GoogleIoT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00180000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F413H-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY,MBEDTLS_CONFIG_FILE=<googleiot_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,GOOGLEIOT,USE_MBED_TLS,STM32F413xx,USE_WIFI
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../Common/GoogleIoT/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/cJSON;../../../../../../Drivers/BSP/Components/es_wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F413H_Discovery.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ssl_cli.c md_wrap.c ssl_tls.c ssl_ciphersuites.c version.c pkcs12.c md.c pk_wrap.c pkcs11.c ecjpake.c x509_crl.c bignum.c base64.c hmac_drbg.c arc4.c cmac.c dhm.c pkparse.c x509_crt.c x509_create.c aria.c platform_util.c rsa_internal.c x509_csr.c des.c version_features.c ecdh.c havege.c ecdsa.c ripemd160.c aes.c pem.c gcm.c pkwrite.c md2.c ctr_drbg.c pkcs5.c sha1.c camellia.c certs.c sha512.c ecp.c error.c ssl_srv.c asn1parse.c md5.c ecp_curves.c sha256.c platform.c threading.c memory_buffer_alloc.c x509.c cipher_wrap.c ssl_cache.c ssl_ticket.c cipher.c entropy.c oid.c timing.c ccm.c pk.c rsa.c x509write_crt.c debug.c xtea.c padlock.c blowfish.c aesni.c x509write_csr.c ssl_cookie.c md4.c asn1write.c entropy_poll.c
  group Application/Common
    ../../../../../Common/Shared/Src/: STM32CubeRTCInterface.c http_lib.c mbedtls_net.c cloud.c net.c paho_timer.c wifi_net.c rfu.c heap.c iot_flash_config.c timedate.c net_tls_mbedtls.c timingSystem.c entropy_hardware_poll.c net_tcp_wifi.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_dac.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_nor.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_crc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_nand.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rng.c stm32f4xx_hal_lptim.c stm32f4xx_hal_cryp.c stm32f4xx_hal_rcc.c stm32f4xx_hal_usart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_spi.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_can.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c flash_f4.c stm32f4xx_it.c
  group Middlewares/Third_Party/MQTTPacket
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTSerializePublish.c MQTTConnectServer.c MQTTUnsubscribeServer.c MQTTDeserializePublish.c MQTTSubscribeClient.c MQTTFormat.c MQTTSubscribeServer.c MQTTPacket.c MQTTConnectClient.c MQTTUnsubscribeClient.c
  group Application/Wifi
    ../Src/: wifi.c es_wifi_io.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON_Utils.c cJSON.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Application/GoogleIoT
    ../../../../../Common/GoogleIoT/Src/: jwt.c googleiot.c
  group Middlewares/Third_Party/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.1.1
