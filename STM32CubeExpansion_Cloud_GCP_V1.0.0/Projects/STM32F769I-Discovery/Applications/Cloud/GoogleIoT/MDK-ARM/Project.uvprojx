# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_GoogleIoT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000-0x817FFFF) IRAM(0x20000000-0x2007BFFF) IRAM_NO_CACHE(0x2007C000-0x2007FFFF) IRAM_NO_CACHE_DEVICE(0x2007C000-0x2007BFFF) IRAM_NO_CACHE_NORMAL(0x2007C200-0x2007FDFF) IRAM2(0x00000000-0x3FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,MBEDTLS_CONFIG_FILE=<googleiot_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,GOOGLEIOT,USE_MBED_TLS,HAS_RTOS,USE_LWIP
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../../../../../Common/GoogleIoT/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/cJSON;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Utilities;../../../../../../Utilities/Fonts;../../../../../../Utilities/Log
  asm include: ../Inc;../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x7c000
  memory RVCT10: RAM 0x0 size 0x4000
  scatter file: .\STM32F769I_Discovery.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/Third_Party/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c ip4.c dhcp.c icmp.c ip4_addr.c etharp.c igmp.c autoip.c
  group Middlewares/Third_Party/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c list.c queue.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_nor.c stm32f7xx_hal.c stm32f7xx_hal_rtc.c stm32f7xx_hal_can.c stm32f7xx_hal_sram.c stm32f7xx_hal_uart.c stm32f7xx_hal_qspi.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim.c stm32f7xx_hal_flash.c stm32f7xx_hal_nand.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_rng.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_hash.c stm32f7xx_hal_usart.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_adc.c stm32f7xx_hal_dac.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_lptim.c stm32f7xx_hal_cryp.c
  group Middlewares/Third_Party/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: err.c netbuf.c netdb.c api_msg.c api_lib.c sockets.c netifapi.c tcpip.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Middlewares/Third_Party/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/GoogleIoT
    ../../../../../Common/GoogleIoT/Src/: jwt.c googleiot.c
  group Middlewares/Third_Party/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Application/Common
    ../../../../../Common/Shared/Src/: net_tcp_lwip.c iot_flash_config.c entropy_hardware_poll.c timedate.c paho_timer.c net_tls_mbedtls.c rfu.c cloud.c mbedtls_net.c timingSystem.c STM32CubeRTCInterface.c http_lib.c net.c heap.c lwip_net.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aesni.c cipher_wrap.c sha256.c asn1write.c md5.c x509.c ssl_cache.c x509_csr.c certs.c xtea.c asn1parse.c arc4.c dhm.c ssl_cli.c havege.c pkcs11.c ssl_tls.c version_features.c gcm.c x509write_csr.c x509_create.c aria.c platform_util.c rsa_internal.c sha1.c oid.c x509write_crt.c md_wrap.c ssl_ciphersuites.c blowfish.c ecdsa.c x509_crt.c x509_crl.c pkparse.c ssl_ticket.c timing.c rsa.c ccm.c debug.c md2.c ssl_cookie.c ecp_curves.c md4.c memory_buffer_alloc.c camellia.c cipher.c entropy.c ripemd160.c pk.c ssl_srv.c pem.c ctr_drbg.c aes.c pkcs5.c pk_wrap.c platform.c version.c pkwrite.c ecjpake.c bignum.c entropy_poll.c cmac.c des.c ecdh.c pkcs12.c md.c threading.c base64.c hmac_drbg.c padlock.c sha512.c ecp.c error.c
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON_Utils.c cJSON.c
  group Middlewares/Third_Party/MQTTPacket
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTDeserializePublish.c MQTTPacket.c MQTTFormat.c MQTTUnsubscribeClient.c MQTTConnectServer.c MQTTSerializePublish.c MQTTUnsubscribeServer.c MQTTSubscribeClient.c MQTTConnectClient.c MQTTSubscribeServer.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c stm32f7xx_it.c main.c flash_f7.c stm32f7xx_hal_timebase_tim.c ethernetif.c
  group Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: timeouts.c mem.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: udp.c raw.c ip.c def.c sys.c inet_chksum.c dns.c tcp_in.c tcp.c init.c stats.c netif.c memp.c pbuf.c tcp_out.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
software components: CMSIS:CORE 5.0.1
