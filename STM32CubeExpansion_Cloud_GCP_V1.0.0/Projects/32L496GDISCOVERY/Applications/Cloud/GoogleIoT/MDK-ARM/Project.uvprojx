# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery_GoogleIoT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496AGIx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496G-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER,MBEDTLS_CONFIG_FILE=<googleiot_mbedtls_config.h>,MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,GOOGLEIOT,USE_MBED_TLS,USE_C2C
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery;../Inc;../../../../../Common/GoogleIoT/Inc;../../../../../Common/Shared/Inc;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src;../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/cJSON;../../../../../../Drivers/BSP/Components/ug96
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\STM32L496G-Discovery.sct
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/ug96/: ug96.c
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c main.c
  group Middlewares/Third_Party/MQTTPacket
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectServer.c MQTTSerializePublish.c MQTTUnsubscribeServer.c MQTTFormat.c MQTTDeserializePublish.c MQTTSubscribeClient.c MQTTConnectClient.c MQTTPacket.c MQTTUnsubscribeClient.c MQTTSubscribeServer.c
  group Application/GoogleIoT
    ../../../../../Common/GoogleIoT/Src/: googleiot.c jwt.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/Third_Party/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Application/Common
    ../../../../../Common/Shared/Src/: http_lib.c iot_flash_config.c heap.c STM32CubeRTCInterface.c net_tcp_c2c.c net.c net_tls_mbedtls.c cloud.c rfu.c mbedtls_net.c timingSystem.c paho_timer.c c2c_net.c entropy_hardware_poll.c timedate.c
    ../Src/: flash_l4.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ecdh.c havege.c version_features.c x509write_crt.c padlock.c sha1.c bignum.c oid.c ssl_ticket.c x509write_csr.c des.c ssl_ciphersuites.c md_wrap.c xtea.c cmac.c md.c ecjpake.c x509_create.c aria.c platform_util.c rsa_internal.c ssl_srv.c dhm.c pkcs11.c version.c certs.c ctr_drbg.c arc4.c asn1parse.c ssl_cli.c pk_wrap.c platform.c aes.c ssl_tls.c gcm.c pkwrite.c pkcs5.c rsa.c ssl_cache.c pem.c entropy.c md2.c md5.c md4.c memory_buffer_alloc.c ecp_curves.c sha256.c ripemd160.c x509_crt.c base64.c cipher_wrap.c x509.c pk.c x509_crl.c pkparse.c x509_csr.c hmac_drbg.c camellia.c ecdsa.c cipher.c pkcs12.c sha512.c threading.c blowfish.c entropy_poll.c ccm.c ecp.c debug.c error.c ssl_cookie.c aesni.c timing.c asn1write.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON_Utils.c cJSON.c
  group Application/C2C
    ../Src/: c2c.c ug96_io.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_io.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_nand.c stm32l4xx_hal_crc.c stm32l4xx_hal_flash.c stm32l4xx_hal_sram.c stm32l4xx_hal_spi.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rtc.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_hash.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_can.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_uart.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_nor.c stm32l4xx_hal_cryp.c stm32l4xx_hal.c
software components: CMSIS:CORE 4.3.0
