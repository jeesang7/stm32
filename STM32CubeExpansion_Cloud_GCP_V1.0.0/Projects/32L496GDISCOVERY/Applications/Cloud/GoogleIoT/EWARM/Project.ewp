# IAR project Project.ewp, settings and files
configuration STM32L496G-Discovery_GoogleIoT (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496AG ST STM32L496AG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L496xx; USE_HAL_DRIVER; MBEDTLS_CONFIG_FILE=<googleiot_mbedtls_config.h>; MQTTCLIENT_PLATFORM_HEADER=paho_mqtt_platform.h; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; GOOGLEIOT; USE_MBED_TLS; USE_C2C
  ICCARM.CCIncludePath2: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/BSP/STM32L496G-Discovery; ../Inc; ../../../../../Common/GoogleIoT/Inc; ../../../../../Common/Shared/Inc; ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src; ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src; ../../../../../../Middlewares/Third_Party/mbedTLS/include; ../../../../../../Middlewares/Third_Party/cJSON; ../../../../../../Drivers/BSP/Components/ug96
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L496G-Discovery.bin
  ILINK.IlinkOutputFile: STM32L496G-Discovery.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/GoogleIoT
    ../../../../../Common/GoogleIoT/Src/: googleiot.c jwt.c
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Application/Common
    ../../../../../Common/Shared/Src/: paho_timer.c cloud.c entropy_hardware_poll.c heap.c iot_flash_config.c net.c rfu.c STM32CubeRTCInterface.c timingSystem.c timedate.c http_lib.c mbedtls_net.c net_tls_mbedtls.c c2c_net.c net_tcp_c2c.c
    ../Src/: flash_l4.c
  group Application/EWARM
    ./: startup_stm32l496xx.s
  group Application/C2C
    ../Src/: c2c.c ug96_io.c
  group Doc
    ../: readme.txt
  group Middlewares/Third_Party/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c cJSON_Utils.c
  group Middlewares/Third_Party/MQTTClient-C
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/Third_Party/MQTTPacket
    ../../../../../../Middlewares/Third_Party/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/ug96/: ug96.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_io.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_can.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
